# IAR project assignment6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\CMSIS; ..\source; ..\MKL46Z
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: assignment6.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: main.c
  group source/driver/Driver_GPIO
    ../source/: Driver_GPIO.c Driver_GPIO.h
  group source/driver/SrecParse
    ../source/: SrecParse.c SrecParse.h
  group source/Hal/clock
    ../source/: clock.c clock.h
  group source/Hal/hal_GPIO
    ../source/: Hal_GPIO.c Hal_GPIO.h
  group source/Hal/Hal_PORT
    ../source/: Hal_PORT.c Hal_PORT.h
  group source/Hal/HaL_UART
    ../source/: Hal_UART.c Hal_UART.h
  group source/Hal/HaL_UART/Hal_Queue
    ../source/: Queue.c Queue.h
  group startup
    ../MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
